# Keil uVision project dmaexplore.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dmaexplore
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.6.0, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:Startup 2.6.3
